SUMMARY = "Linux Framebuffer Benchmark"
SECTION = "console/utils"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"

SRC_URI = "git://github.com/OpenInkpot/fbmark.git;protocol=git"
SRCREV  = "master"
S = "${WORKDIR}/git"
