IMAGE_INSTALL = "initramfs-boot-eb600 busybox base-passwd kernel-modules"
