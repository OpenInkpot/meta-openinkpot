include ecore.inc
